<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vlp_sink_02</value></param>
<param><key>author</key><value>Jamesy Jean-Michel</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Does Trilateration with RSS</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>VLP MS Project</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CrxCtx1</value></param>
<param><key>value</key><value>1.37567074</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CrxCtx2</value></param>
<param><key>value</key><value>1.37229190</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CrxCtx3</value></param>
<param><key>value</key><value>1.42731873</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CrxCtx4</value></param>
<param><key>value</key><value>1.21686524</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>FOV_RX</value></param>
<param><key>value</key><value>90</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>G_filter</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RX_area</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX1_f</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX1_location</value></param>
<param><key>value</key><value>1.105, .455, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX2_f</value></param>
<param><key>value</key><value>300000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX2_location</value></param>
<param><key>value</key><value>.505, 1.155, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX3_f</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX3_location</value></param>
<param><key>value</key><value>.505, .455, 1.42</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX4_f</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX4_location</value></param>
<param><key>value</key><value>1.105, 1.115, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TXn_ampl</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TXn_height</value></param>
<param><key>value</key><value>2.15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lamb_order</value></param>
<param><key>value</key><value>0.88</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>x</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>y</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>z_rx</value></param>
<param><key>value</key><value>1.42</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>Position</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>X position</value></param>
<param><key>name</key><value>"Receiver (2D) Position"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>xmax</key><value>1.45</value></param>
<param><key>xmin</key><value>0</value></param>
<param><key>ymax</key><value>1.37</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>z_rx</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>y</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_1</value></param>
<param><key>const</key><value>x</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_2</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_3</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0</value></param>
<param><key>freq</key><value>TX1_f</value></param>
<param><key>len</key><value>fft_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_0</value></param>
<param><key>freq</key><value>TX4_f</value></param>
<param><key>len</key><value>fft_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_1</value></param>
<param><key>freq</key><value>TX3_f</value></param>
<param><key>len</key><value>fft_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_2</value></param>
<param><key>freq</key><value>TX2_f</value></param>
<param><key>len</key><value>fft_size</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>optical_2_distance_ff</key>
<param><key>id</key><value>optical_2_distance_ff_0</value></param>
<param><key>CrxCtx</key><value>CrxCtx1</value></param>
<param><key>Trx_filter</key><value>1.0</value></param>
<param><key>lamb_order</key><value>lamb_order</value></param>
<param><key>rx_area</key><value>RX_area</value></param>
<param><key>rx_fov</key><value>FOV_RX</value></param>
<param><key>tx_ampl</key><value>TXn_ampl</value></param>
<param><key>tx_height</key><value>TXn_height</value></param>
</block>
<block>
<key>optical_2_distance_ff</key>
<param><key>id</key><value>optical_2_distance_ff_1</value></param>
<param><key>CrxCtx</key><value>CrxCtx2</value></param>
<param><key>Trx_filter</key><value>1.0</value></param>
<param><key>lamb_order</key><value>lamb_order</value></param>
<param><key>rx_area</key><value>RX_area</value></param>
<param><key>rx_fov</key><value>FOV_RX</value></param>
<param><key>tx_ampl</key><value>TXn_ampl</value></param>
<param><key>tx_height</key><value>TXn_height</value></param>
</block>
<block>
<key>optical_2_distance_ff</key>
<param><key>id</key><value>optical_2_distance_ff_2</value></param>
<param><key>CrxCtx</key><value>CrxCtx3</value></param>
<param><key>Trx_filter</key><value>1.0</value></param>
<param><key>lamb_order</key><value>lamb_order</value></param>
<param><key>rx_area</key><value>RX_area</value></param>
<param><key>rx_fov</key><value>FOV_RX</value></param>
<param><key>tx_ampl</key><value>TXn_ampl</value></param>
<param><key>tx_height</key><value>TXn_height</value></param>
</block>
<block>
<key>optical_2_distance_ff</key>
<param><key>id</key><value>optical_2_distance_ff_3</value></param>
<param><key>CrxCtx</key><value>CrxCtx4</value></param>
<param><key>Trx_filter</key><value>1.0</value></param>
<param><key>lamb_order</key><value>lamb_order</value></param>
<param><key>rx_area</key><value>RX_area</value></param>
<param><key>rx_fov</key><value>FOV_RX</value></param>
<param><key>tx_ampl</key><value>TXn_ampl</value></param>
<param><key>tx_height</key><value>TXn_height</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>-2</value></param>
<param><key>name</key><value>Trilateration Output</value></param>
<param><key>nconnections</key><value>3</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>2D Position</value></param>
<param><key>label1</key><value>(x, y, z) values</value></param>
<param><key>label2</key><value>Time+freq</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>vlp_trilat_fixed_4in_ff</key>
<param><key>id</key><value>vlp_trilat_fixed_4in_ff_0</value></param>
<param><key>tx1_coords</key><value>TX1_location</value></param>
<param><key>tx2_coords</key><value>TX2_location</value></param>
<param><key>tx3_coords</key><value>TX3_location</value></param>
<param><key>tx4_coords</key><value>TX4_location</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>optical_2_distance_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>optical_2_distance_ff_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>optical_2_distance_ff_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>optical_2_distance_ff_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_1</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>goertzel_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>goertzel_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>goertzel_fc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>goertzel_fc_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>optical_2_distance_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>optical_2_distance_ff_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_1</source_block_id><sink_block_id>optical_2_distance_ff_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_2</source_block_id><sink_block_id>optical_2_distance_ff_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>Position</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_1</source_block_id><sink_block_id>blocks_complex_to_mag_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_2</source_block_id><sink_block_id>blocks_complex_to_mag_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>optical_2_distance_ff_0</source_block_id><sink_block_id>vlp_trilat_fixed_4in_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>optical_2_distance_ff_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>optical_2_distance_ff_1</source_block_id><sink_block_id>vlp_trilat_fixed_4in_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>optical_2_distance_ff_1</source_block_id><sink_block_id>blocks_null_sink_3</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>optical_2_distance_ff_2</source_block_id><sink_block_id>vlp_trilat_fixed_4in_ff_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>optical_2_distance_ff_2</source_block_id><sink_block_id>blocks_null_sink_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>optical_2_distance_ff_3</source_block_id><sink_block_id>vlp_trilat_fixed_4in_ff_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>optical_2_distance_ff_3</source_block_id><sink_block_id>vlp_trilat_fixed_4in_ff_0</sink_block_id><source_key>1</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_trilat_fixed_4in_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlp_trilat_fixed_4in_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>vlp_trilat_fixed_4in_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp_trilat_fixed_4in_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vlp_trilat_fixed_4in_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
